# IAR project beer_machine_mqtt.ewp, settings and files
configuration beer_machine_mqtt (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; DEVICE_ONLINE; DEBUG_ASSERT; MQTT_TASK
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Src/board; ../Src/utils; ../Src/circle_buffer; ../Src/debug/log; ../Src/debug/log/serial_uart; ../Src/debug/cpu; ../Src/debug/log/SEGGER_RTT_V612j/RTT; ../Src/debug/log/SEGGER_RTT_V612j/Syscalls; ../Src/serial; ../Src/serial_uart_hal; ../Src/http; ../Src/net; ../Src/tasks; ../Src/m6312; ../Src/wifi; ../Src/at; ../Src/md5; ../Src/ntp; ../Src/socket; ../Src/led; ../Src/utils; ../Src/tm1629a; ../Src/bootloader_if; ../Src/flash_utils; ../Src/firmware_version; ../Src/cjson; ../Src/lib/src; ../Src/m6312; ../Src/debug/log/uart_console; ../Src/mqtt/inc; ../Src/mqtt/net
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: beer_machine_mqtt.bin
  ILINK.IlinkOutputFile: beer_machine_mqtt.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/user
    ../Src/: adc.c dma.c freertos.c gpio.c iwdg.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c
  group Application/user/at
    ../Src/at/: at.c
  group Application/user/bsp
    ../Src/board/: beer_machine.c
  group Application/user/debug
    ../Src/debug/log/: log.c
  group Application/user/debug/cpu
    ../Src/debug/cpu/: cpu_utils.c
  group Application/user/debug/segger_rtt
    ../Src/debug/log/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Src/debug/log/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group Application/user/debug/uart_console
    ../Src/debug/log/uart_console/: uart_console.c
  group Application/user/lib
    ../Src/lib/src/: circle_buffer.c printf.c st_cm3_uart_hal_driver.c tiny_timer.c xuart.c
  group Application/user/m6312
    ../Src/m6312/: m6312.c
  group Application/user/mqtt
    ../Src/mqtt/src/: mqtt_client.c mqtt_packet.c mqtt_socket.c
  group Application/user/mqtt/mqtt_net
    ../Src/mqtt/net/: mqttuart.c
  group Application/user/tasks
    ../Src/tasks/: mqtt_task.c net_task.c tasks_init.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
