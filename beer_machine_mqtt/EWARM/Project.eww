<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\beer_machine_mqtt.ewp</path>
  </project>
  <batchBuild />
</workspace>
